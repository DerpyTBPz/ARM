# Keil uVision project lab2.uvproj, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: NUC140VE3CN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: lab2
  c flags: Optim=2 v6Lang=1 v6LangP=5 wLevel=3
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Source Group 1
    ./: startup_NUC1xx.s __main.s SystemInit.s reg_def.s
