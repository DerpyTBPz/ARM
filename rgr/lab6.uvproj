# Keil uVision project lab6.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: NUC140VE3CN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: lab6
  c flags: Optim=1 wLevel=2
  c include: .\CMSIS\CM0\DeviceSupport\Nuvoton\NUC1xx;.\CMSIS\CM0\CoreSupport;.\NuvotonPlatform_Keil\Include
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Source Group 1
    ./: startup_NUC1xx.s main.c SystemInit.s reg_def.s
