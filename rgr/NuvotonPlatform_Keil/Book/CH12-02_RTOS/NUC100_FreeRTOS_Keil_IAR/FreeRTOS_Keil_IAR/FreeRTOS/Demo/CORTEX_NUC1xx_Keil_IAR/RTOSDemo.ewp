# IAR project RTOSDemo.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: NUC140xE Nuvoton NUC140xE
  ICCARM.CCDefines: IAR_ARM_CM0
  ICCARM.CCDiagSuppress: Pe550, Pa082, Pa039
  ICCARM.CCIncludePath2: ..\common\include; ..\..\source\include; $PROJ_DIR$; NUC1xxBSP\NuvotonPlatform_Keil\Include; NUC1xxBSP\NuvotonPlatform_Keil\Include\Driver; NUC1xxBSP\CMSIS\CM0; User_Demo\include
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: $PROJ_DIR$
  OBJCOPY.OOCOutputFile: RTOSDemo.bin
  ILINK.IlinkOutputFile: RTOSDemo.out
  ILINK.IlinkIcfFile: RTOSDemo.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: dl-stnl0.a
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Demo files
    ../Common/Minimal/: AltBlckQ.c AltBlock.c AltPollQ.c AltQTest.c BlockQ.c blocktim.c countsem.c death.c dynamic.c flash.c flop.c GenQTest.c integer.c IntQueue.c PollQ.c QPeek.c recmutex.c semtest.c
    ./: IntQueueTimer.c main.c
    ParTest/: ParTest.c
    User_Demo/: Queue_Test.c Smpl_DrvUART.c Thread_Test.c
  group FreeRTOS files
    ../../Source/portable/MemMang/: heap_2.c
    ../../Source/: list.c queue.c tasks.c
    ../../Source/portable/IAR/ARM_CM0/: port.c portasm.s
  group lib
    NUC1xxBSP/NuvotonPlatform_Keil/Src/Driver/: retarget.c
  group System
    NUC1xxBSP/CMSIS/CM0/: core_cm0.c system_NUC1xx.c
    NUC1xxBSP/CMSIS/CM0/startup/iar/: startup_NUCxxx_iar.s
