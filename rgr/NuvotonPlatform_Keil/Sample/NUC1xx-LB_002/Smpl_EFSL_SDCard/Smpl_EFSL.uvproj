# Keil uVision project Smpl_EFSL.uvproj, settings and files
target Smpl_EFSL (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: Smpl_EFSL
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1
  c include: .\;..\..\..\..\CMSIS\CM0\DeviceSupport\Nuvoton\NUC1xx;..\..\..\Include;..\..\..\Include\Driver;..\..\..\Include\NUC1xx-LB_002;.\efsl\inc;.\efsl\inc\interfaces;.\efsl\conf
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_NUC1xx.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS files
    ../../../../CMSIS/CM0/CoreSupport/: core_cm0.c
    ../../../../CMSIS/CM0/DeviceSupport/Nuvoton/NUC1xx/: system_NUC1xx.c
    ../../../../CMSIS/CM0/DeviceSupport/Nuvoton/NUC1xx/startup/arm/: startup_NUC1xx.s
  group Source files
    ./: Smpl_EFSL.c
  group Library files
    ../../../Src/Driver/: DrvUART.c DrvSYS.c DrvGPIO.c DrvSPI.c retarget.c
    ../../../Src/NUC1xx-LB_002/: DrvSDCard.c
  group src files
    ./efsl/src/: ui.c time.c plibc.c partition.c mkfs.c ls.c ioman.c fs.c file.c fat.c extract.c efs.c disc.c dir.c debug.c
    ./efsl/src/interfaces/: NUC1xx_spi.c
